# Repository angelrajpal/Digiwatch

## EAGLE design Hardware/Top/DigiWatch-TOP.brd

Parts:
C2, C5, C6, C7: 1u; C0603
C8, C9: CAPACITOR0603; C0603
C10, C11: 300p; C0603
C12: 10u; C0805
C13, C15, C17, C18, C19: 2.2uF; C0402
C14: 100n; C0603
C16: 10uF; C0603
C20, C21: 4.7u; C0603
CHRG2: MCP73831; SOT23-5
CORTEX1: CORTEX_DEBUG_PTH; 2X5-PTH-1.27MM
D1, D4, D5: SCHOTTKY-USC; USC
J2: CONN_02; 1X02
L2: 10u; L0603
LDO2: MIC5504; SOT23-5
LED3: RED; LED-0603
LED4: BLUE; LED-0603
R3, R4: 1k; R0603
R5, R6, R8, R9: 10k; R0603
R7: 390k; R0603
R11: RESISTOR0603; R0603
R12, R13, R14, R15: 100k; R0603
SD2: MICROSD
SW1, SW2, SW5: SWITCH.MOM; TACTILE_SWITCH_SMD_6.2MM_TALL
SW3, SW4: SPST-PTS830GG140-COPY.1-3; BUTTON-GULLWING
U2: NRF52832_MODULE_MDBT42; BLE_MODULE_RAYTAC_MDBT42
U3: DISP_OLED_UG-2864HSWEG01-NO-WRAPAROUND; UG-2864HSWEG01_0.96IN_NO-WRAPAROUND
U4: PCF8523; SO8; DIGIKEY 568-5306-1-ND
USB2: USB.MICRO-BIGGERPADS; USB-MICRO-01.BIGGERPADS
XTAL2: 32.768kHz; 2-SMD.NOLEAD.2.0MMTO1.2MM
XTAL3: 32.7680kHz; 2-SMD.NOLEAD.2.0MMTO1.2MM

Connections:
3.3V: C2.1, C6.1, C12.2, C17.2, C19.2, CORTEX1.1 (VCC), D1.- (C), LDO2.5 (OUT), R5.2, R8.2, R9.2, R15.2, SD2.4 (VDD), U2.11 (VDD), U3.6 (VBAT), U3.9 (VDD), U4.8 (VDD)
BATT: R13.1, R14.2
CD1: SD2.CD1 (CARD_DETECT)
CD2: SD2.CD2 (CARD_DETECT1)
CHRG.STAT: CHRG2.1 (STAT), R12.1
CS.OLED: U3.13 (/CS)
DC.OLED: U3.15 (DC/I2C_SA0)
DFU: SW3.3 (B), U2.34 (P0.20)
DTR: C14.1
FRST: U2.38 (P0.22)
GND: C2.2, C5.1, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.1, C16.1, C17.1, C18.1, C19.1, C20.2, C21.1, CHRG2.2 (VSS), CORTEX1.3 (GND), CORTEX1.5 (GND), CORTEX1.7 (KEY), CORTEX1.9 (GNDDTCT), J2.1, LDO2.2 (GND), LED3.C, LED4.C, R6.1, R7.2, R11.1, R14.1, R15.1, SD2.6 (VSS), SD2.MT1 (GND), SD2.MT2 (GND1), SW1.B1 (3), SW1.B2 (4), SW2.B1 (3), SW2.B2 (4), SW3.1 (A), SW4.3 (B), SW5.B1 (3), SW5.B2 (4), U2.1 (GND), U2.12 (GND), U2.24 (GND), U2.39 (GND), U3.1 (NC(GND)), U3.8 (VSS), U3.10 (BS0), U3.12 (BS2), U3.29 (VLSS), U3.30 (NC(GND)), U4.4 (VSS), USB2.5 (GND)
LED1: R3.2, U2.31 (P0.17)
LED2: R4.2, U2.33 (P0.19)
MISO: SD2.7 (DATA_OUT), U2.28 (P0.14)
MOSI: SD2.3 (DATA_IN), U2.27 (P0.13), U3.19 (D1/SPI_SDIN/I2C_SDA)
unnamed: R6.2, U3.11 (BS1)
unnamed: R7.1, U3.26 (IREF)
unnamed: C13.2, U3.2 (C2P)
unnamed: C8.2, U2.13 (P0.00/XL1), XTAL2.P$1 (1)
unnamed: C13.1, U3.3 (C2N)
unnamed: C9.1, U2.14 (P0.01/XL2), XTAL2.P$2 (2)
unnamed: C15.2, U3.4 (C1P)
unnamed: C15.1, U3.5 (C1N)
unnamed: LED3.A, R3.1
unnamed: LED4.A, R4.1
unnamed: L2.1, U2.10 (DCC)
unnamed: C7.1, L2.2, U2.9 (DEC4)
unnamed: C16.2, U3.28 (VCC)
unnamed: C18.2, U3.27 (VCOMH)
unnamed: CHRG2.5 (PROG), R11.2
unnamed: U4.2 (OSCO), XTAL3.P$1 (1)
unnamed: U4.1 (OSCI), XTAL3.P$2 (2)
P0.09/NFC1: C11.1, U2.22 (P0.09)
P0.10/NFC2: C10.1, U2.23 (P0.10)
RESET: C14.2, CORTEX1.10 (!RESET), D1.+ (A), R5.1, SW4.1 (A), U2.35 (P0.21/RESET)
RESET.OLED: U3.14 (/RES)
RXD: U2.21 (P0.08)
SCK: SD2.5 (SCLK), U2.26 (P0.12), U3.18 (D0/SPI_SCLK/I2C_SCK)
SCL: R8.1, U2.3 (P0.26), U4.6 (SCL)
SD.CS: SD2.2 (CS)
SDA: R9.1, U2.2 (P0.25), U4.5 (SDA)
SW1: SW1.A1 (1), SW2.A1 (1), SW5.A1 (1)
SWCLK: CORTEX1.4 (SWDCLK/TCK), U2.36 (SWDCLK)
SWDIO: CORTEX1.2 (SWDIO/TMS), U2.37 (SWDIO)
SWO: CORTEX1.6 (SWO/TDO), U2.32 (P0.18/SWO)
TXD: U2.19 (P0.06)
USB+: USB2.3 (D+)
USB-: USB2.2 (D-)
VBATT: U4.3 (VBAT)
VIN: C5.2, C21.2, CHRG2.4 (VIN), D4.- (C), D5.- (C), LDO2.1 (IN), LDO2.3 (EN), R12.2
VLIPO: C20.1, CHRG2.3 (VBAT), D4.+ (A), J2.2, R13.2
V_USB: D5.+ (A), USB2.1 (V+)

Notes on the sheet:
Microcontroller Reset Circuit
100nF+10K @ 3.3V = ~1.2ms to 0.7VCC
SPECIAL / PORT / PIN ON PACKAGE / GPIO(D_or_A) / Comments SDA / P0.25 / pin2 / D25 SCL / P0.26 / pin3 / D26 none / P0.27 / pin4 / D27 none / P0.28 / pin5 / D28_or_A4 / (low drive, low frequency IO) none / P0.29 / pin6 / D29_or_A5 / (low drive, low frequency IO) none / P0.30 / pin7 / D30_or_A6 none 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
SPECIAL / PORT / PIN ON PACKAGE / GPIO(D_or_A) / Comments none / P0.02 / pin15 / D2_or_A0 none / P0.03 / pin16 / D3_or_A1 none / P0.04 / pin17 / D4_or_A2 none / P0.05 / pin18 / D5_or_A3 TXD / P0.06 / pin19 / D6 / but reserved for Serial communication and programming none / P0.07 / pin20 / D7 RXD / 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
SPECIAL / PORT / PIN ON PACKAGE / GPIO(D_or_A) / Comments Factory Reset / P0.22 / pin38 / DO NOT USE FOR ANY GPIO SWDIO / none / pin37 / reserved-not available for general GPIO SWCLK / none / pin36 / reserved-not available for general GPIO RESET / P0.21 / pin35 / reserved-not available for general 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
Some pins are noted as reserved and not available for general GPIO (unless you are an adavanced user) I2C, SPI, and SWD pins can be repurposed if you know what you are doing For Milestones, avoid repurposing NFC pins. For P0.19 (LED2), Adafruit's Bluetooth Low Energy libraries use this pin to indic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
PIN_DFU / P0.20: If this pin is detected to be at GND level at startup, the board will enter a special serial bootloader mode and will not execute any user code, going straight into bootloader mode. If you wish to use this pin as a standard GPIO, make sure that it is pulled high with a pullup resis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
Additional notes for advanced users only
Connect MISO, MOSI, and SCK to appropriate pins on microcontroller. Those are SPI pins and are generally prespecified. You have more flexibility with the SD.CS pin.
I2C Address = 0x68h
Back-up battery if desired
Power Management
RTC
SD card
Buttons
Clock
Cortex Debugger

Board: 2 copper layers, 52 parts (2 on the bottom side), 39 nets, no tracks yet.

## Commit log

2020-06-04 test
